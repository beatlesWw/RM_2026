# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,ARM_MATH_CM4,__CC_ARM,__TARGET_FPU_VFP,__FPU_PRESENT=1U
  c misc: --diag_suppress=188 --no-multibyte-chars --diag_suppress=186
  c include: .\Start;.\Library;.\System;.\INS;.\Hardware;.\Motor;.\Function;.\Control;.\Model;.\CarBody;.\UI;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Start
    ./Start/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f40_41xxx.s stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group System
    ./System/: Delay.c Delay.h TIM.c TIM.h UART.c UART.h CAN.c CAN.h
  group Library
    ./Library/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_cec.c stm32f4xx_cec.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dfsdm.c stm32f4xx_dfsdm.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_dma2d.c stm32f4xx_dma2d.h stm32f4xx_dsi.c stm32f4xx_dsi.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_fmpi2c.c stm32f4xx_fmpi2c.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_lptim.c stm32f4xx_lptim.h stm32f4xx_ltdc.c stm32f4xx_ltdc.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_qspi.c stm32f4xx_qspi.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sai.c stm32f4xx_sai.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spdifrx.c stm32f4xx_spdifrx.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group INS
    ./INS/: ins_task.c ins_task.h kalman_filter.c kalman_filter.h QuaternionEKF.c QuaternionEKF.h
  group Hardware
    ./Hardware/: LED.c LED.h Buzzer.c Buzzer.h Remote.c Remote.h BMI088.c BMI088.h STP.c STP.h
  group Motor
    ./Motor/: GM6020.c GM6020.h MF9025.c MF9025.h DM_J8009.c DM_J8009.h
  group Function
    ./Function/: LinkCheck.c LinkCheck.h Warming.c Warming.h CToC.c CToC.h CloseLoopControl.c CloseLoopControl.h AttitudeAlgorithms.c AttitudeAlgorithms.h IMUTemperatureControl.c IMUTemperatureControl.h
  group Control
    ./Control/: PID.c PID.h
  group Model
    ./Model/: Observer.c Observer.h Leg_Controller.c Leg_Controller.h LQR.c LQR.h Locomotion_Controller.c Locomotion_Controller.h
    ./CarBody/: MotionEstimation.c MotionEstimation.h
  group CarBody
    ./CarBody/: RefereeSystem.c RefereeSystem.h RefereeSystem_CRCTable.c RefereeSystem_CRCTable.h Ultra_CAP.c Ultra_CAP.h Chassis.c
    ./Carbody/: Chassis.h
    ./Hardware/: Chassis_Middleware.c Chassis_Middleware.h
  group UI
    ./UI/: ui_default_Change_0.c ui_default_Change_0.h ui_default_Group1_0.c ui_default_Group1_0.h ui_default_Group2_0.c ui_default_Group2_0.h ui_default_Group2_1.c ui_default_Group2_1.h ui_default_Group2_2.c ui_default_Group2_2.h ui_default_Group2_3.c ui_default_Group2_3.h ui_default_Group2_4.c ui_default_Group2_4.h ui_default_Update_0.c ui_default_Update_0.h ui_default_Update1_0.c ui_default_Update1_0.h ui_interface.c ui_interface.h ui_types.h UI.c UI.h UI_Middleware.c UI_Middleware.h
  group User
    ./User/: main.c RM_C.h Parameter.h Data.c Data.h Lock.c Lock.h arm_math.h arm_cortexM4lf_math.lib stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
